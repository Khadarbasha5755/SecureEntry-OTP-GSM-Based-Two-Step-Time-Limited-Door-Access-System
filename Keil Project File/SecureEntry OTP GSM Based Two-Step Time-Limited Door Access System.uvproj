# Keil uVision project SecureEntry OTP GSM Based Two-Step Time-Limited Door Access System.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: SecureEntry OTP GSM Based Two-Step Time-Limited Door Access System +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s delay.c door.c door_cgram.c eint1.c gsm.c kpm.c lcd.c main.c otp.c rtc.c spi.c spi_eeprom.c switch.c uart.c user.c
